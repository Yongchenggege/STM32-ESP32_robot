# Keil uVision project A.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\AC5)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: A +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10_HD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\APP;.\Public;.\fft_lib;.\hardware;.\hardware\a4950;.\hardware\encoder;.\hardware\hc_sr04;.\hardware\I2C;.\hardware\motor;.\hardware\mpu6050;.\hardware\OLED;.\hardware\pid;.\hardware\Public;.\hardware\PWM;.\hardware\tcs34725;.\hardware\timer;.\hardware\uart;.\FreeRTOS\FreeRTOS-Kernel\include;.\FreeRTOS\FreeRTOS-Kernel;.\FreeRTOS\FreeRTOS-Kernel\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_it.c
    ./FreeRTOS/FreeRTOS-Kernel/: FreeRTOSConfig.h
  group startup
    ./User/: startup_stm32f10x_md.s
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_tim.c
  group Public
    ./Public/: stdelay.c
  group Freertos_src
    ./FreeRTOS/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Freertos_port
    ./FreeRTOS/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
    ./FreeRTOS/FreeRTOS-Kernel/portable/RVDS/ARM_CM3/: port.c
  group APP
    ./hardware/a4950/: A4950.c
    ./hardware/encoder/: encoder.c
    ./hardware/hc_sr04/: hc_sr04.c
    ./hardware/I2C/: IIC.C
    ./hardware/OLED/: OLED.c
    ./hardware/pid/: pid.c
    ./hardware/PWM/: pwm.c
    ./hardware/tcs34725/: Colorlight.c tcs34725.c
    ./hardware/uart/: usart.c
    ./hardware/mpu6050/: mpu_IIC.c MPU_6050.c inv_mpu.c inv_mpu_dmp_motion_driver.c
